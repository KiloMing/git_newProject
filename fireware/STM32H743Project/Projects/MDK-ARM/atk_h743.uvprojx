# Keil uVision project atk_h743.uvprojx, settings and files
target TFTLCD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h743 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,LV_CONF_INCLUDE_SIMPLE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\User;..\..\Middlewares;..\..\Middlewares\include;..\..\Middlewares\porting;..\..\User\UI
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group User
    ../../User/: main.c stm32h7xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_sram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_sdram.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/ADC/: adc_1.c
    ../../Drivers/BSP/DMA/: dma_1.c
    ../../Drivers/BSP/LCD_FUNCTION/: lcd_function.c
    ../../Drivers/BSP/SDRAM/: sdram.c
    ../../Drivers/BSP/RTC/: rtc.c
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/TOUCH/: touch.c ctiic.c gt9xxx.c ft5206.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/IIC/: myiic.c
  group Readme
    ../../: readme.txt
  group LVGL/Core
    ../../Middlewares/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../../Middlewares/src/display/: lv_display.c
    ../../Middlewares/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../Middlewares/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../Middlewares/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../../Middlewares/src/font/: lv_font.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_30.c
    ../../Middlewares/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../Middlewares/src/layouts/flex/: lv_flex.c
    ../../Middlewares/src/layouts/grid/: lv_grid.c
    ../../Middlewares/src/layouts/: lv_layout.c
    ../../Middlewares/src/: lv_init.c
    ../../Middlewares/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../Middlewares/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../Middlewares/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../Middlewares/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../Middlewares/src/osal/: lv_os.c lv_os_none.c
    ../../Middlewares/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../Middlewares/src/stdlib/: lv_mem.c
    ../../Middlewares/src/themes/default/: lv_theme_default.c
    ../../Middlewares/src/themes/: lv_theme.c
    ../../Middlewares/src/themes/mono/: lv_theme_mono.c
    ../../Middlewares/src/themes/simple/: lv_theme_simple.c
    ../../Middlewares/src/tick/: lv_tick.c
    ../../Middlewares/src/widgets/3dtexture/: lv_3dtexture.c
    ../../Middlewares/src/widgets/animimage/: lv_animimage.c
    ../../Middlewares/src/widgets/arc/: lv_arc.c
    ../../Middlewares/src/widgets/arclabel/: lv_arclabel.c
    ../../Middlewares/src/widgets/bar/: lv_bar.c
    ../../Middlewares/src/widgets/button/: lv_button.c
    ../../Middlewares/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../Middlewares/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Middlewares/src/widgets/canvas/: lv_canvas.c
    ../../Middlewares/src/widgets/chart/: lv_chart.c
    ../../Middlewares/src/widgets/checkbox/: lv_checkbox.c
    ../../Middlewares/src/widgets/dropdown/: lv_dropdown.c
    ../../Middlewares/src/widgets/gif/: lv_gif.c
    ../../Middlewares/src/widgets/image/: lv_image.c
    ../../Middlewares/src/widgets/imagebutton/: lv_imagebutton.c
    ../../Middlewares/src/widgets/ime/: lv_ime_pinyin.c
    ../../Middlewares/src/widgets/keyboard/: lv_keyboard.c
    ../../Middlewares/src/widgets/label/: lv_label.c
    ../../Middlewares/src/widgets/led/: lv_led.c
    ../../Middlewares/src/widgets/line/: lv_line.c
    ../../Middlewares/src/widgets/list/: lv_list.c
    ../../Middlewares/src/widgets/lottie/: lv_lottie.c
    ../../Middlewares/src/widgets/menu/: lv_menu.c
    ../../Middlewares/src/widgets/msgbox/: lv_msgbox.c
    ../../Middlewares/src/widgets/objx_templ/: lv_objx_templ.c
    ../../Middlewares/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../../Middlewares/src/widgets/roller/: lv_roller.c
    ../../Middlewares/src/widgets/scale/: lv_scale.c
    ../../Middlewares/src/widgets/slider/: lv_slider.c
    ../../Middlewares/src/widgets/span/: lv_span.c
    ../../Middlewares/src/widgets/spinbox/: lv_spinbox.c
    ../../Middlewares/src/widgets/spinner/: lv_spinner.c
    ../../Middlewares/src/widgets/switch/: lv_switch.c
    ../../Middlewares/src/widgets/table/: lv_table.c
    ../../Middlewares/src/widgets/tabview/: lv_tabview.c
    ../../Middlewares/src/widgets/textarea/: lv_textarea.c
    ../../Middlewares/src/widgets/tileview/: lv_tileview.c
    ../../Middlewares/src/widgets/win/: lv_win.c
    ../../Middlewares/src/draw/convert/: lv_draw_buf_convert.c
    ../../Middlewares/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../../Middlewares/src/libs/bin_decoder/: lv_bin_decoder.c
  group LVGL/Application
    ../../Middlewares/porting/: lv_port_disp.c lv_port_indev.c
    ../../User/UI/: ui.c page.c testvalue.c chart.c setting.c app_interface.c lv_arc_demo.c
